# Keil uVision project G474-FOC.uvprojx, settings and files
target G474-FOC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: G474-FOC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../src/app/app;../src/app/cmd;../src/app/status;../src/app/perf;../src/app/log;../src/app/control;../src/algorithm/sixstep;../src/algorithm/foc;../src/third_party;../src/bsp/board;../src/bsp/pwm;../src/bsp/hall;../src/bsp/adc_cur;../src/bsp/adc_vbus;../src/bsp/uart;../src/bsp/time
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Application/User/App
    ../src/app/app/: app_state.c app.c
    ../src/app/cmd/: app_cmd.c
    ../src/app/status/: app_status.c
    ../src/app/perf/: perf.c perf_print.c
    ../src/app/log/: app_log.c
    ../src/app/control/: app_control.c
  group Application/User/Algo
    ../src/algorithm/sixstep/: alg_sixstep.c
  group Application/User/BSP
    ../src/bsp/board/: board.c
    ../src/bsp/pwm/: pwm.c pwm_io.c pwm_duty.c pwm_bridge.c
    ../src/bsp/hall/: hall.c
    ../src/bsp/adc_cur/: adc_cur.c
    ../src/bsp/adc_vbus/: adc_vbus.c
    ../src/bsp/uart/: uart.c
software components: CMSIS:CORE 4.3.0
